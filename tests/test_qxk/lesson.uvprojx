# Keil uVision project lesson.uvprojx, settings and files
target dbg (6070000::V6.7::.\ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IROM(0x00000000,0x040000) IRAM(0x20000000,0x008000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: lesson
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: .;..\qpc\include;..\qpc\src;..\qpc\ports\arm-cm\qxk\armclang;..\qpc\3rd_party\CMSIS\Include;..\qpc\3rd_party\ek-tm4c123gxl
  asm define: Stack_Size=1024 Heap_Size=0
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --entry Reset_Handler
  group Applicatioin
    ./: bsp.c main.c bsp.h
  group ek-tm4c123gxl
    ../qpc/3rd_party/ek-tm4c123gxl/: system_TM4C123GH6PM.c TM4C123GH6PM.h
    ../qpc/3rd_party/ek-tm4c123gxl/arm/: startup_TM4C123GH6PM.s
  group qp
    ../qpc/src/qf/: qep_hsm.c qep_msm.c qf_act.c qf_actq.c qf_defer.c qf_dyn.c qf_mem.c qf_ps.c qf_qact.c qf_qeq.c qf_qmact.c qf_time.c
    ../qpc/src/qxk/: qxk.c qxk_mutex.c qxk_sema.c qxk_xthr.c
  group qp_port
    ../qpc/ports/arm-cm/qxk/armclang/: qep_port.h qf_port.h qs_port.h qxk_port.c qxk_port.h
